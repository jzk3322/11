# Keil uVision project flpower_bl_msd.uvprojx, settings and files
target default (6190000::V6.19::ARMCLANG)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flpower_bl_msd +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c include: ..\board;..\drivers\air_lib\AIR32_USB-FS-Device_Driver\inc;..\drivers\air_lib\AIR32F10xLib\inc;..\drivers\cmsis;..\user\usb_config;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../user/: FAT16.c FAT16.h hex.c hex.h main.c
  group user/usb_config
    ../user/usb_config/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group board
    ../board/: air32f10x_it.c board.c board_flash.c board_delay.c board_serial.c
  group lib/std_lib
    ../drivers/air_lib/AIR32F10xLib/src/: misc.c air32f10x_flash.c air32f10x_gpio.c air32f10x_usart.c air32f10x_rcc_ex.c air32f10x_rcc.c air32f10x_exti.c
  group lib/cmsis
    ../drivers/cmsis/air32/source/arm/: startup_air32f10x.s
    ../drivers/cmsis/air32/source/: system_air32f10x.c
  group lib/usb
    ../drivers/air_lib/AIR32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
