# Keil uVision project flpower.uvprojx, settings and files
target debug (6190000::V6.19::ARMCLANG)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flpower +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\AIR32F10xLib\inc;..\Libraries\CMSIS\Include;..\Libraries;..\middlewares\FreeRTOS\FreeRTOS-Kernel\include;..\middlewares\FreeRTOS\FreeRTOS-Kernel\portable\GCC\ARM_CM3;..\app;..\bsp;..\component;..\middlewares\lvgl;..\middlewares\lvgl\lvgl;..\middlewares\lvgl\lvgl\porting;..\component;..\Libraries\hal_rtos_drv;..\Libraries\unities;..\app\ui
  asm include: ..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../app/: main.c FreeRTOSConfig.h app_gui.c app_init.c app_pd.c app_log.c app_pd_log.c device.h device.c app_sample.c app_power.c
  group app\ui
    ../app/ui/: ui.c ui.h ui_events.h ui_helpers.c ui_helpers.h gui_refresh.c gui.c gui_indev.c gui.h ui_helpers_ex.h ui_events.c
    ../app/ui/components/: ui_comp_hook.c
    ../app/ui/fonts/: ui_font_Font20.c ui_font_Font40.c
    ../app/ui/screens/: ui_SP_ScreenPower.c ui_SM_Screen.c
  group bsp
    ../bsp/: bsp.c board.c board_it.c
  group component
    ../component/: lcd_spi_drv.c lcd_st7789.c encoder.c general_in.c general_out.c led.c ina226.c FUSB302_UFP.c PD_UFP_Protocol.c
  group CORE
    ../Libraries/STARTUP/arm/: startup_air32f10x.s
    ../Libraries/CMSIS/Device/air32f103/: system_air32f103.c
  group freertos
    ../middlewares/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../middlewares/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../middlewares/FreeRTOS/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
  group FWLib
    ../Libraries/AIR32F10xLib/src/: air32f10x_dma.c air32f10x_gpio.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_spi.c air32f10x_usart.c misc.c air32f10x_tim.c air32f10x_pwr.c air32f10x_bkp.c air32f10x_i2c.c
  group lvgl\porting
    ../middlewares/lvgl/: lv_conf.h
    ../middlewares/lvgl/lvgl/porting/: lv_port_disp.c
  group lvgl\core
    ../middlewares/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl\draw
    ../middlewares/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../middlewares/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl\extra
    ../middlewares/lvgl/lvgl/src/extra/: lv_extra.c
    ../middlewares/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../middlewares/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../middlewares/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../middlewares/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../middlewares/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../middlewares/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../middlewares/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ../middlewares/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../middlewares/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../middlewares/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c
    ../middlewares/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../middlewares/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../middlewares/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../middlewares/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../middlewares/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../middlewares/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../middlewares/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../middlewares/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../middlewares/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../middlewares/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../middlewares/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../middlewares/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group lvgl\font
    ../middlewares/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl\hal
    ../middlewares/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl\misc
    ../middlewares/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl\widgets
    ../middlewares/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl\examples
    ../middlewares/lvgl/lvgl/examples/widgets/arc/: lv_example_arc_2.c
  group hal_rtos_drv
    ../Libraries/hal_rtos_drv/: hal_rtos_drv.c hal_rtos_drv.h hal_rtos_i2c.c hal_rtos_i2c.h hal_simulate_i2c.c hal_simulate_i2c.h
  group unities
    ../Libraries/unities/: sys_log.c string_extend.c
